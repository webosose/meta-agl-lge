FILESEXTRAPATHS_append := "${THISDIR}/files:"

SRC_URI_append = " \
    file://0001-Homescreen-2017-landscape-support.patch \
"

