FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_remove = "file://hdmi-a-1-270.cfg"
SRC_URI += "file://hdmi-a-1-0.cfg"
