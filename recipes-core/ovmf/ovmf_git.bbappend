FILESEXTRAPATHS_append := "${THISDIR}/files:"

SRC_URI_append = " \
    file://0001-VfrCompile-fix-invalid-comparison-between-pointer-an.patch \
"
